/**
 * @file Easy_Func.c
 * @author Pop_Cat (xuzhicheng@longshuo-tech.com)
 * @brief 
 * @version 0.0.0.24.11.08
 * @date 2025年09月14日
 * 
 * 
 */

/* -------------------------------------------------------------------------------------------------------------------------- */
/* 头文件引用 */
/* -------------------------------------------------------------------------------------------------------------------------- */
#include "Easy_Func.h"  // 引入Easy_Func头文件，可能包含CRC计算相关的函数声明和宏定义
#include "math.h"
/* -------------------------------------------------------------------------------------------------------------------------- */
/* 私有宏定义 */
/* -------------------------------------------------------------------------------------------------------------------------- */


// 此部分为私有宏定义区域，目前未定义任何宏
/* -------------------------------------------------------------------------------------------------------------------------- */
/* 内部函数声明 */
/* -------------------------------------------------------------------------------------------------------------------------- */


// 此部分为内部函数声明区域，目前未声明任何内部函数
/* -------------------------------------------------------------------------------------------------------------------------- */
/* 私有类型定义 */
/* -------------------------------------------------------------------------------------------------------------------------- */


// 此部分为私有类型定义区域，目前未定义任何类型
/* -------------------------------------------------------------------------------------------------------------------------- */
/* 外部变量引用声明 */
/* -------------------------------------------------------------------------------------------------------------------------- */


// 此部分为外部变量引用声明区域，目前未声明任何外部变量
/* -------------------------------------------------------------------------------------------------------------------------- */
/* 文件作用域对象 */
/* -------------------------------------------------------------------------------------------------------------------------- */
/* CRC 计算临时值 用于非连续内存的CRC校验 */
uint16_t Temp_CRC_Value = 0xFFFF ;  // 初始化CRC计算临时值为0xFFFF，作为CRC计算的初始值

/* -------------------------------------------------------------------------------------------------------------------------- */
/* 只读数据 */
/* -------------------------------------------------------------------------------------------------------------------------- */
/* CRC余式表 */
const uint16_t CRC_Table[256] = {  // CRC计算查表法使用的余式表，包含256个16位值
    0x0000, 0xc0c1, 0xc181, 0x0140, 0xc301, 0x03c0, 0x0280, 0xc241,
    0xc601, 0x06c0, 0x0780, 0xc741, 0x0500, 0xc5c1, 0xc481, 0x0440,
    0xcc01, 0x0cc0, 0x0d80, 0xcd41, 0x0f00, 0xcfc1, 0xce81, 0x0e40,
    0x0a00, 0xcac1, 0xcb81, 0x0b40, 0xc901, 0x09c0, 0x0880, 0xc841,
    0xd801, 0x18c0, 0x1980, 0xd941, 0x1b00, 0xdbc1, 0xda81, 0x1a40,
    0x1e00, 0xdec1, 0xdf81, 0x1f40, 0xdd01, 0x1dc0, 0x1c80, 0xdc41,
    0x1400, 0xd4c1, 0xd581, 0x1540, 0xd701, 0x17c0, 0x1680, 0xd641,
    0xd201, 0x12c0, 0x1380, 0xd341, 0x1100, 0xd1c1, 0xd081, 0x1040,
    0xf001, 0x30c0, 0x3180, 0xf141, 0x3300, 0xf3c1, 0xf281, 0x3240,
    0x3600, 0xf6c1, 0xf781, 0x3740, 0xf501, 0x35c0, 0x3480, 0xf441,
    0x3c00, 0xfcc1, 0xfd81, 0x3d40, 0xff01, 0x3fc0, 0x3e80, 0xfe41,
    0xfa01, 0x3ac0, 0x3b80, 0xfb41, 0x3900, 0xf9c1, 0xf881, 0x3840,
    0x2800, 0xe8c1, 0xe981, 0x2940, 0xeb01, 0x2bc0, 0x2a80, 0xea41,
    0xee01, 0x2ec0, 0x2f80, 0xef41, 0x2d00, 0xedc1, 0xec81, 0x2c40,
    0xe401, 0x24c0, 0x2580, 0xe541, 0x2700, 0xe7c1, 0xe681, 0x2640,
    0x2200, 0xe2c1, 0xe381, 0x2340, 0xe101, 0x21c0, 0x2080, 0xe041,
    0xa001, 0x60c0, 0x6180, 0xa141, 0x6300, 0xa3c1, 0xa281, 0x6240,
    0x6600, 0xa6c1, 0xa781, 0x6740, 0xa501, 0x65c0, 0x6480, 0xa441,
    0x6c00, 0xacc1, 0xad81, 0x6d40, 0xaf01, 0x6fc0, 0x6e80, 0xae41,
    0xaa01, 0x6ac0, 0x6b80, 0xab41, 0x6900, 0xa9c1, 0xa881, 0x6840,
    0x7800, 0xb8c1, 0xb981, 0x7940, 0xbb01, 0x7bc0, 0x7a80, 0xba41,
    0xbe01, 0x7ec0, 0x7f80, 0xbf41, 0x7d00, 0xbdc1, 0xbc81, 0x7c40,
    0xb401, 0x74c0, 0x7580, 0xb541, 0x7700, 0xb7c1, 0xb681, 0x7640,
    0x7200, 0xb2c1, 0xb381, 0x7340, 0xb101, 0x71c0, 0x7080, 0xb041,
    0x5000, 0x90c1, 0x9181, 0x5140, 0x9301, 0x53c0, 0x5280, 0x9241,
    0x9601, 0x56c0, 0x5780, 0x9741, 0x5500, 0x95c1, 0x9481, 0x5440,
    0x9c01, 0x5cc0, 0x5d80, 0x9d41, 0x5f00, 0x9fc1, 0x9e81, 0x5e40,
    0x5a00, 0x9ac1, 0x9b81, 0x5b40, 0x9901, 0x59c0, 0x5880, 0x9841,
    0x8801, 0x48c0, 0x4980, 0x8941, 0x4b00, 0x8bc1, 0x8a81, 0x4a40,
    0x4e00, 0x8ec1, 0x8f81, 0x4f40, 0x8d01, 0x4dc0, 0x4c80, 0x8c41,
    0x4400, 0x84c1, 0x8581, 0x4540, 0x8701, 0x47c0, 0x4680, 0x8641,
    0x8201, 0x42c0, 0x4380, 0x8341, 0x4100, 0x81c1, 0x8081, 0x4040,
};


/* -------------------------------------------------------------------------------------------------------------------------- */
/* 函数定义 */
/* -------------------------------------------------------------------------------------------------------------------------- */
/**
 * @brief 计算指定长度的数据的CRC校验值
 * 
 * @param Data 
 * @param Length 
 * 
 * @return uint16_t 
 */
uint16_t CRC_Calculate( uint8_t Data[  ] , uint32_t Length )
{
    uint16_t CRC_Value = 0xFFFF ;

    while( Length-- ) 
    {
        CRC_Value = ( CRC_Value >> 8 ) ^ CRC_Table[ ( CRC_Value ^ *Data++ ) & 0xFF ]; //原理参考直接计算法
    }

    return CRC_Value ;
}

/**
 * @brief CRC计算器复位函数
 * @details 此函数用于将CRC计算器的临时值重置为初始值0xFFFF
 */
void CRC_Calculator_Reset( void )
{
    // 将CRC计算的临时值设置为初始值0xFFFF
    Temp_CRC_Value = 0xFFFF ;
}


/**
 * @brief CRC计算器输入函数
 * 
 * @param data 指向待计算CRC的数据块的指针
 * @param size 待计算CRC的数据块的大小
 * 
 */
void CRC_Calculator_Input( const uint8_t *data, uint32_t size )
{
    if( data == NULL ) return;

    for( uint32_t i = 0 ; i < size ; i++ ) //  遍历数据块计算CRC值
    {
        Temp_CRC_Value = ( Temp_CRC_Value >> 8 ) ^ CRC_Table[ ( Temp_CRC_Value ^ *data ) & 0xFF ]; //原理参考直接计算法
        data++;
    }
}

/**
 * @brief CRC计算器输出函数
 * 
 * 
 * @return uint16_t CRC计算结果
 */
uint16_t CRC_Calculator_Output( void )
{
    return Temp_CRC_Value ;
}


/**
 * @brief 计算从active角度到target角度的最短路径差值（有符号）
 * 
 * @param target      目标角度，单位为度（范围：[0,360)）
 * @param active      起始角度，单位为度（范围：[0,360)）
 * @return double     从active到target的变化量，范围：(-180, 180]
 *                    正值表示顺时针增加，负值表示逆时针减少
 * 
 * @note 示例：
 *       active=45, target=60  → 返回 +15  (顺时针转15度)
 *       active=60, target=45  → 返回 -15  (逆时针转15度)
 *       active=1,  target=359 → 返回 -2   (逆时针转2度，比顺时针转358度短)
 */
double Ang_360_Diff_Calculate(double target, double active) {
    double diff = fmod(target - active, 360.0);
    
    // 调整到 (-180, 180] 范围
    if (diff > 180.0) {
        diff -= 360.0;
    } else if (diff <= -180.0) {
        diff += 360.0;
    }
    
    // 处理浮点误差导致的 -0.0
    if (fabs(diff) < 1e-10) {
        diff = 0.0;
    }
    
    return diff;
}

/**
 * @brief 计算从active角度到target角度的最短路径差值（有符号）
 * 
 * @param target      目标角度，单位为度（范围：[0,360)）
 * @param active      起始角度，单位为度（范围：[0,360)）
 * @return double     从active到target的变化量，范围：(-180, 180]
 *                    正值表示顺时针增加，负值表示逆时针减少
 * 
 * @note 示例：
 *       active=45, target=60  → 返回 +15  (顺时针转15度)
 *       active=60, target=45  → 返回 -15  (逆时针转15度)
 *       active=1,  target=359 → 返回 -2   (逆时针转2度，比顺时针转358度短)
 */
float Ang_360_Diff_Calculate_F(float target, float active) {
    float diff = fmod(target - active, 360.0);
    
    // 调整到 (-180, 180] 范围
    if (diff > 180.0) {
        diff -= 360.0;                    
    } else if (diff <= -180.0) {
        diff += 360.0;
    }
    
    // 处理浮点误差导致的 -0.0
    if (fabs(diff) < 1e-10) {
        diff = 0.0;
    }
    
    return diff;
}

/**
 * @brief 计算从当前角度到目标角度的最短步数差值（有符号）
 * 
 * @param Current 
 * @param Limit 
 * @param Target 
 * 
 * @return int32_t 
 */
int32_t Counter_GetDelta(uint32_t Current, uint32_t Limit, uint32_t Target) {
    if (Current == Target) {
        return 0;
    }
    
    // 计算顺时针（增加）需要多少步
    uint32_t steps_clockwise;
    if (Target >= Current) {
        steps_clockwise = Target - Current;
    } else {
        steps_clockwise = Limit - Current + Target;
    }
    
    // 计算逆时针（减少）需要多少步
    uint32_t steps_counterclockwise;
    if (Current >= Target) {
        steps_counterclockwise = Current - Target;
    } else {
        steps_counterclockwise = Current + Limit - Target;
    }
    
    // 选择步数少的方向
    if (steps_clockwise <= steps_counterclockwise) {
        return (int32_t)steps_clockwise;
    } else {
        return -(int32_t)steps_counterclockwise;
    }
}
