# Keil uVision project Project.uvprojx, settings and files
target PY32F031x8_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 13138CodeHex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,PY32F031x8
  c include: .\GFX;.\GFX_Test;.\GFX_Test\generated;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\PY32F031\Include;.\Drivers\PY32F031_HAL_Driver\Inc;.\Inc;.\0 - User;.\3 - Function;.\4 - Hardware;.\5 - Basic;.\6 - MCU;.\7 - C Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Lib
    ./Drivers/PY32F031_HAL_Driver/Src/: py32f031_ll_adc.c py32f031_ll_comp.c py32f031_ll_cordic.c py32f031_ll_crc.c py32f031_ll_dma.c py32f031_ll_exti.c py32f031_ll_gpio.c py32f031_ll_i2c.c py32f031_ll_lcd.c py32f031_ll_lptim.c py32f031_ll_pwr.c py32f031_ll_rcc.c py32f031_ll_rtc.c py32f031_ll_spi.c py32f031_ll_tim.c py32f031_ll_usart.c py32f031_ll_utils.c
  group Startup
    ./Src/: py32f031_it.c system_py32f031.c startup_py32f031xx.s
  group User
    ./0 - User/: main.c User_Main.c User.h User_Config.h
  group GFX
    ./GFX/: GFX.c GFX_Port.c Area.c
  group GFX Test
    ./GFX_Test/: GFX_Hardware_Test.c
    ./GFX_Test/generated/: gfx_test_assets.c
  group Input
    ./3 - Function/: Key.c Key_Port.c
  group Hardware
    ./4 - Hardware/: HKND_St7789W3.c BY25Q80.c
  group Basic
    ./5 - Basic/: Delay.c Delay_Port.c Tick.c Tick_Port.c Power_Port.c
  group MCU
    ./6 - MCU/: MCU.c
  group C Lib
    ./7 - C Lib/: Easy_Func.c
software components: CMSIS:CORE 5.3.0
