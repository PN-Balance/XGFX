/**
 * @file Tick.c
 * @author Pop_Cat (xuzhicheng@longshuo-tech.com)
 * @brief 
 * @version 0.0.0.24.11.08
 * @date 2025年09月14日
 * 
 * 
 */

/* -------------------------------------------------------------------------------------------------------------------------- */
/* 头文件引用 */
/* -------------------------------------------------------------------------------------------------------------------------- */
#include "Tick.h"

/* -------------------------------------------------------------------------------------------------------------------------- */
/* 私有宏定义 */
/* -------------------------------------------------------------------------------------------------------------------------- */


/* -------------------------------------------------------------------------------------------------------------------------- */
/* 内部函数声明 */
/* -------------------------------------------------------------------------------------------------------------------------- */


/* -------------------------------------------------------------------------------------------------------------------------- */
/* 私有类型定义 */
/* -------------------------------------------------------------------------------------------------------------------------- */


/* -------------------------------------------------------------------------------------------------------------------------- */
/* 外部变量引用声明 */
/* -------------------------------------------------------------------------------------------------------------------------- */


/* -------------------------------------------------------------------------------------------------------------------------- */
/* 文件作用域对象 */
/* -------------------------------------------------------------------------------------------------------------------------- */
Tick_t Tick ;

/* -------------------------------------------------------------------------------------------------------------------------- */
/* 只读数据 */
/* -------------------------------------------------------------------------------------------------------------------------- */


/* -------------------------------------------------------------------------------------------------------------------------- */
/* 函数定义 */
/* -------------------------------------------------------------------------------------------------------------------------- */


/**
 * @brief Tick 初始化
 * 
 */
void Tick_Init( void )
{
    Tick = 0 ;

    Tick_Port_Timer_Init(  );
}

/**
 * @brief 获取 Tick 
 * 
 * @return Tick_t 
 */
Tick_t Tick_Get_Tick( void )
{
    return Tick ;
}


/**
 * @brief 检查是否已经过指定持续时间
 * 
 * @param Start 起始时间点
 * @param Duration 要检查的持续时间
 * @return true 已经过了Duration时间
 * @return false 尚未经过Duration时间
 * 
 */
bool Tick_Elaspe( const Tick_t Start , const Tick_t Duration )
{
    Tick_t Current = Tick ;
    
    // 处理计数器溢出的情况
    if( Current >= Start)
    {
        // 没有发生溢出，直接比较差值
        return ( Current - Start ) >= Duration;
    }
    else
    {
        // 发生溢出，计算回绕后的时间差
        return ( TICK_MAX - Start + Current + 1 ) >= Duration;
    }
}
/**
 * @brief 获取经过的时间
 * 
 * @param Tick_Last     起始时间点
 *  
 * @return Tick_t   经过的时间
 */
Tick_t Tick_Get_Elaspe( const Tick_t Tick_Last )
{
    Tick_t Current = Tick;
    
    // 处理计数器溢出的情况
    if (Current >= Tick_Last)
    {
        // 没有发生溢出，直接计算差值
        return Current - Tick_Last;
    }
    else
    {
        // 发生溢出，计算回绕后的时间差
        return (TICK_MAX - Tick_Last) + Current + 1;
    }
}

/**
 * @brief 更新 Tick 定时器 ，检查溢出
 * 
 * @param Timer 
 * @return true 溢出 - 更新定时器的最后时间为当前
 * @return false 没溢出
 */
bool Tick_Timer_Updata( Tick_Timer Timer )
{
    if( !Timer->Enable )
    {
        return false ;
    }

    bool Over = Tick_Elaspe( Timer->Last_Tick , Timer->Period );

    if( Over )
    {
        Timer->Last_Tick = Tick ;
    }

    return Over ;
}

/**
 * @brief 使能或者失能 定时器
 * 
 * @param Timer 
 * @param Enable 
 */
void Tick_Timer_Set_Active( Tick_Timer Timer , bool Enable )
{
    Timer->Enable = Enable ;
}

/**
 * @brief 定时器初始化
 * 
 * @param Timer 
 * @param Period 周期
 * @param Enable 使能或者失能
 */
void Tick_Timer_Init( Tick_Timer Timer , Tick_t Period , bool Enable )
{
    Timer->Last_Tick = Tick ;
    Timer->Enable = Enable ;
    Timer->Period = Period ; 
}


/**
 * @brief 1 ms 定时 回调
 * 
 */
void Tick_CallBack_1ms_Timer( void )
{
    Tick++ ;
}
